Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-04-30T15:40:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Apr 30 15:40:34 2020* Host: NCL-PI02* Database: C:\Users\connm\AppData\Local\Temp\{241F1ACA-1BBE-43D2-B20E-8C0B9FC9387D}\ifc* Database version: 5507* Database creation date: Thu Apr 30 15:40:34 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Apr 30 15:40:34 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Apr 30 15:40:34 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: WhitesideFreeStandingCanopy, NBS_AbleCanopiesLtd_OpenSddShltrs_WhitesideFreeStandingCanopy:WhitesideFreeStandingCanopy:191519
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_20_65_78_58 (Uniclass2015); Material: NBS_Plastic_Clear, NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AbleCanopiesLtd_OpenSddShltrs_WhitesideFreeStandingCanopy; ManufacturerName: Able Canopies Ltd; ManufacturerURL: www.ablecanopies.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/fsoaol4q; NBSDescription: Open sided shelters; NBSReference: 45-05-75/315; ProductInformation: www.ablecanopies.co.uk/canopies/free-standing-canopies/whiteside-free-standing-canopy.html; Revision: n/a; Uniclass2015Title: Open sided shelters; Uniclass2015Code: Pr_20_65_78_58; Uniclass2015Version: Products v1.17; Version: 1
Type - NBS_Data - FrameMaterial: Steel tube section; FrameFinish: Galvanised powder coated, galvanised, powder coated; FrameColour: n/a; RoofCovering: Can be fitted with a choice of either 16mm structured polycarbonate or 5mm solid polycarbonate roof panels; OpeningsDoors: n/a; OpeningsWindows: n/a; OpeningsRoofVents: n/a; IntegralServices: n/a; RainwaterDrainage: Guttering and downpipes included as standard; Accessories: Side fills, Signage; ProjectionWidth: 2m - 4m; WallPlates: n/a; RoofSystem: Able Canopies alunimium barrel glaze system; PostsSize: n/a; PostsMaterial: n/a; WeatherResistance: n/a; FirePerformance: Sheets stable at very high tempertures - low expansion
Type - Pset_FurnitureTypeCommon - Description: Free standing canopy; MainColor: n/a; NominalDepth: 0 mm; NominalHeight: 0 mm; NominalLength: 0 mm; Style: Canopy
Type - IFC - IfcExportAs: IfcBuildingElementProxyType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Generic Models; CodePerformance: n/a; Color: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: 25 years; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: sales@ablecanopies.co.uk; Material: n/a; ModelNumber: n/a; ModelReference: Whiteside Free Standing Canopy; Name: OpenSidedShelters_WhitesideFreeStandingCanopy_AbleCanopiesLtd; NominalWidth: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: 10 years; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
